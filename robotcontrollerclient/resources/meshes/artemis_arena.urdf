Commit message: Added UCF mesh

File: robotcontrollerclient/resources/meshes/artemis_arena.urdf (robot description, URDF)
Before this commit: robot arena_mesh, 1 links, 0 joints
Links:
- link map: geometry visual mesh filename=artemis_arena.glb
